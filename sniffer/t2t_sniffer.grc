<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfid</value></param>
<param><key>author</key><value>Amjad Majid</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>RFID sniffer</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>RFID_sniffer</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ant</value></param>
<param><key>value</key><value>antenna</value></param>
<param><key>gui_hint</key><value>4,2,1,2</value></param>
<param><key>label0</key><value>RX2</value></param>
<param><key>label1</key><value>TX/RX</value></param>
<param><key>label2</key><value>J1</value></param>
<param><key>label3</key><value>J2</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>RX2</value></param>
<param><key>option1</key><value>TX/RX</value></param>
<param><key>option2</key><value>J1</value></param>
<param><key>option3</key><value>J2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_c</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>gui_hint</key><value>3,0,1,2</value></param>
<param><key>label</key><value>RX Tune Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_slider</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,4</value></param>
<param><key>label</key><value>center freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>800e6</value></param>
<param><key>step</key><value>.5e6</value></param>
<param><key>stop</key><value>900e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.5</value></param>
<param><key>stop</key><value>31.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate_</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>3,2,1,2</value></param>
<param><key>label</key><value>Sampling Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>uhd_version_info</value></param>
<param><key>value</key><value>uhd.get_version_string()</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>UHD Version</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>usrp_device_info</value></param>
<param><key>value</key><value>uhd.get_version_string()</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>label</key><value>Device Information</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>short_id</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>RX2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>UHD device address args</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/amjed/Desktop/main_t2t_sniffer/data.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>Set number of FFT bins</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Default Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.8680e9+ 2.414e9*0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Set gain in dB (default is midpoint)</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0</value></param>
<param><key>cutoff_freq</key><value>samp_rate/8</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>samp_rate/20</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>2048 </value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>update_rate</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e5*2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spec</value></param>
<param><key>label</key><value>Subdev</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stream_args</value></param>
<param><key>label</key><value>Set additional stream args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>ant</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>float(freq_c)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>args</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>spec</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>stream_args</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>wire_format</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>update_rate</value></param>
<param><key>label</key><value>Set GUI widget update rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wire_format</value></param>
<param><key>label</key><value>Wire format</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>low_pass_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
